DESCRIPTION = "A loader interface around multiple config file formats."
HOMEPAGE = "http://docs.pylonsproject.org/projects/plaster/en/latest/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
SRC_URI[md5sum] = "c59345a67a860cfcaa1bd6a81451399d"
inherit setuptools3
inherit pypi
