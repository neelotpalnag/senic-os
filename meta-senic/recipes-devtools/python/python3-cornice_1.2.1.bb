SUMMARY = "Define Web Services in Pyramid."
HOMEPAGE = "https://github.com/mozilla-services/cornice"
LICENSE = "MPL-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a5bfa0b879709dc2d0908ff07efa5b4d"

inherit setuptools3
inherit pypi
SRC_URI[md5sum] = "b53eb7561148459659762b029efbd04c"
