SUMMARY = "A library to work with OSRAM lightify."
HOMEPAGE = "https://github.com/aneumeier/python-lightify"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d2794c0df5b907fdace235a619d80314"

inherit setuptools3
inherit pypi
SNC_DEVPI_INDEX = "getsenic/master"
SRC_URI[sha256sum] = "f10fb4d8c8fe98ea85660900987cd9955c7673195ee3558555dc528a5c24a58f"
