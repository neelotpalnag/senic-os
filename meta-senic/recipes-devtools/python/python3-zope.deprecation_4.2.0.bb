SUMMARY = "Zope Deprecation Infrastructure"
HOMEPAGE = "http://github.com/zopefoundation/zope.deprecation"
LICENSE = "ZPL-2.1"
LIC_FILES_CHKSUM = "file://COPYRIGHT.txt;md5=9c79c4dbe7ac16ff23aa2072665b3d9a \
                    file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

inherit setuptools3
inherit pypi

SRC_URI[md5sum] = "5d110c34ab7b313490c1a8533bbdc7a0"
