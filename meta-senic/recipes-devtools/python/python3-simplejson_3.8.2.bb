SUMMARY = "Simple, fast, extensible JSON encoder/decoder for Python"
HOMEPAGE = "http://cheeseshop.python.org/pypi/simplejson"
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=c6338d7abd321c0b50a2a547e441c52e"

SRCNAME = "simplejson"
SRC_URI[md5sum] = "53b1371bbf883b129a12d594a97e9a18"

inherit setuptools
inherit pypi

