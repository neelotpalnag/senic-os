DESCRIPTION = "A Philips Hue Python library"
HOMEPAGE = "https://github.com/studioimaginaire/phue"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
SRC_URI[md5sum] = "0c41a3cf27a5dbd86f63730096433b50"
inherit setuptools3
inherit pypi
