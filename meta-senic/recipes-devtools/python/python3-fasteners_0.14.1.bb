SUMMARY = "A python package that provides useful locks."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"
inherit setuptools3 pypi
SRC_URI[md5sum] = "fcb13261c9b0039d9b1c4feb9bc75e04"

