SUMMARY = "Define Web Services in Pyramid."
HOMEPAGE = "https://github.com/mozilla-services/cornice"
LICENSE = "MPL-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a5bfa0b879709dc2d0908ff07efa5b4d"

inherit setuptools
inherit pypi
SRC_URI[md5sum] = "e41c3f1c1130cff6587c40b6064120b6"
