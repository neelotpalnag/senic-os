HOMEPAGE = "https://github.com/martinblech/xmltodict"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=01441d50dc74476db58a41ac10cb9fa2"

inherit setuptools
inherit pypi

SRC_URI[md5sum] = "9f955947db085485873ac68154e88069"
