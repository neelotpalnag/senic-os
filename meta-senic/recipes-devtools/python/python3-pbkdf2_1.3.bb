DESCRIPTION = "PKCS#5 v2.0 PBKDF2 Module"
HOMEPAGE = "http://www.dlitz.net/software/python-pbkdf2/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
SRC_URI[md5sum] = "40cda566f61420490206597243dd869f"
inherit setuptools3
inherit pypi
