SUMMARY = "Bluetooth GATT SDK for Python"
HOMEPAGE = "https://github.com/getsenic/gatt-python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit setuptools3
inherit pypi

SRC_URI[md5sum] = "8e7a0dae4f1d3aabb8a5a0fa28b075da"

