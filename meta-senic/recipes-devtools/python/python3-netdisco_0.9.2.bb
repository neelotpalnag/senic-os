SUMMARY = "Discover devices on your local network"
HOMEPAGE = "https://github.com/home-assistant/netdisco"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=f4eda51018051de136d3b3742e9a7a40"
inherit setuptools3
inherit pypi
SRC_URI[md5sum] = "8b3b261ed6e2aa2d3d076c4e11b9ea1a"
