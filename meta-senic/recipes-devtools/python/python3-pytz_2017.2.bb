SUMMARY = "World timezone definitions, modern and historical"
HOMEPAGE = "http://pythonhosted.org/pytz/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit setuptools
inherit pypi

PYPI_PACKAGE_EXT = "zip"
SRC_URI[md5sum] = "f89bde8a811c8a1a5bac17eaaa94383c"

