SUMMARY = "A library for deferring decorator actions"
HOMEPAGE = "http://pylonsproject.org"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://${THISDIR}/licenses/REPOZE_LICENSE.txt;md5=2513261c6e403f9e6fd2ae3ce8f2c710"

RDEPENDS_${PN} += "python-contextlib python-core python-lang python-pkgutil python-re python-unittest"
SRC_URI[md5sum] = "56bc5e6756e4bda37bcdb94f74a72b8f"
