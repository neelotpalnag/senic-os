SUMMARY = "Bluetooth GATT SDK for Python"
HOMEPAGE = "https://github.com/getsenic/gatt-python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit setuptools3
inherit pypi

SRC_URI[md5sum] = "a952715763a6b076d65889339961704b"

