DESCRIPTION = "Tools for using a Web Server Gateway Interface stack"
HOMEPAGE = "http://pythonpaste.org/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
PYPI_PACKAGE = "Paste"
SRC_URI[md5sum] = "1231e14eae62fa7ed76e9130b04bc61e"
inherit pypi setuptools3

