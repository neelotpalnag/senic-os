SUMMARY = "WebSocket client for python. hybi13 is supported."
HOMEPAGE = "https://github.com/websocket-client/websocket-client.git"
LICENSE = "LGPL"
LIC_FILES_CHKSUM = "file://LICENSE;md5=18b09a20dd186af4fd60f1a08311628c"
PYPI_PACKAGE = "websocket_client"

inherit setuptools3
inherit pypi

SRC_URI[md5sum] = "73d87aa16a2212da448b30aca9c5bf3b"
