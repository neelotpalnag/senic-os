SUMMARY = "Integrated process monitor for developing and reloading daemons.  "
HOMEPAGE = "https://github.com/Pylons/hupper"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit setuptools3
inherit pypi

SRC_URI[md5sum] = "26e77da7d5ac5858f59af050d1a6eb5a"

