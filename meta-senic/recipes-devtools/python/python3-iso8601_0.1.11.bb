DESCRIPTION = "Simple module to parse ISO 8601 dates"
HOMEPAGE = "https://bitbucket.org/micktwomey/pyiso8601"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
SRC_URI[md5sum] = "b06d11cd14a64096f907086044f0fe38"

