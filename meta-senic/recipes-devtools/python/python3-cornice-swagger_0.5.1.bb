SUMMARY = "Generate swagger from a Cornice application."
HOMEPAGE = "https://cornices.github.io/cornice.ext.swagger/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e"
PYPI_PACKAGE = "cornice_swagger"

inherit setuptools3
inherit pypi
SRC_URI[md5sum] = "6f7849e6d52ac94584fea621d10210cc"

