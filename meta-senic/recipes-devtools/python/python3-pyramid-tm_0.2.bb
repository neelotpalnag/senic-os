SUMMARY = "A package which allows Pyramid requests to join the active transaction"
HOMEPAGE = "http://docs.pylonsproject.org/projects/pyramid-tm/en/latest/"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://${THISDIR}/licenses/REPOZE_LICENSE.txt;md5=2513261c6e403f9e6fd2ae3ce8f2c710"
PYPI_PACKAGE = "pyramid_tm"

SRC_URI[md5sum] = "4f110a70bc5162bb2d2b1242349d06af"

inherit pypi setuptools3
