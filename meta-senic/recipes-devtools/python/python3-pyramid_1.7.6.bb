SUMMARY = "The Pyramid Web Framework, a Pylons project"
HOMEPAGE = "https://trypyramid.com/"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://${THISDIR}/licenses/REPOZE_LICENSE.txt;md5=2513261c6e403f9e6fd2ae3ce8f2c710"

SRC_URI[md5sum] = "cfd8422e647fad1e2585747c540cd3b2"

