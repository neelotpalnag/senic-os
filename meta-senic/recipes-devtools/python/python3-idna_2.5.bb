SUMMARY = "Internationalised Domain Names in Applications"
HOMEPAGE = "https://github.com/kjd/idna"
LICENSE = "BSD-3-Clause & Python-2.0 & Unicode"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=134bdad79491c37bdae32811572b4bc6"

SRC_URI[md5sum] = "fc1d992bef73e8824db411bb5d21f012"

BBCLASSEXTEND = "native nativesdk"

