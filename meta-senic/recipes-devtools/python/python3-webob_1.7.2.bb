SUMMARY = "WSGI request and response object"
HOMEPAGE = "http://webob.org/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://docs/license.txt;md5=8ed3584bcc78c16da363747ccabc5af5"
PYPI_PACKAGE = "WebOb"
inherit setuptools
inherit pypi
SRC_URI[md5sum] = "ab54739f9f716c3cdf66ad3dc4816113"
