SUMMARY = "Waitress WSGI server"
HOMEPAGE = "https://github.com/Pylons/waitress"
LICENSE = "ZPL"
LIC_FILES_CHKSUM = "file://COPYRIGHT.txt;md5=9c79c4dbe7ac16ff23aa2072665b3d9a \
                    file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

inherit setuptools3
inherit pypi

SRC_URI[md5sum] = "b968f39e95d609f6194c6e50425d4bb7"
