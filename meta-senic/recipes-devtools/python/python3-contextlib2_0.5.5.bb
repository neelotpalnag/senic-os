SUMMARY = "Backports and enhancements for the contextlib module"
HOMEPAGE = "http://contextlib2.readthedocs.org"
LICENSE = "PSF"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=43d1c7827e8fad6454b553caf0e1d734"
inherit setuptools
inherit pypi
SRC_URI[md5sum] = "95fe420941ebc64951cd9d89edc41870"
