SUMMARY = "Linux filesystem events monitoring"
HOMEPAGE = "http://github.com/seb-m/pyinotify"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit setuptools3
inherit pypi

SRC_URI[md5sum] = "8e580fa1ff3971f94a6f81672b76c406"
