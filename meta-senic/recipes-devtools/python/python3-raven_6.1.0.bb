SUMMARY = "Raven is a client for Sentry (https://getsentry.com)"
HOMEPAGE = "https://github.com/getsentry/raven-python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b9a4414e08f0571d55184531cefc131b"

inherit setuptools
inherit pypi

SRC_URI[md5sum] = "74f5c6d28382d6cc235145cf4b0f764a"
