SUMMARY = "An implementation of time.monotonic() for Python 2 & < 3.3"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"
inherit setuptools3 pypi
SRC_URI[md5sum] = "34351251d1a67667a25cd7673d2e44bf"

