DESCRIPTION = "Nuimo SDK for Python on Linux"
HOMEPAGE = "https://github.com/getsenic/nuimo-linux-python"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
SRC_URI[md5sum] = "2a596bd1f8603486a564bd3646ca8193"
inherit setuptools3
inherit pypi
