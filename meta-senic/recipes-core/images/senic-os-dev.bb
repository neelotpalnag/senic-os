require senic-os.bb

IMAGE_INSTALL += " \	
	htop \
	usbutils \
	vim \
	tree \
	sudo \
	git \
	curl \
	bash \
	python-pip \
	python3-pip \
	iperf3 \ 
	stress \
	bootstrap-ansible \
"
