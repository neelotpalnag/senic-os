inherit pypi setuptools
SUMMARY = "A microframework based on Werkzeug, Jinja2 and good intentions"
DESCRIPTION = "\
meld3 is an HTML/XML templating system for Python which keeps template markup and dynamic rendering logic separate from one another."
HOMEPAGE = "http://entrian.com/PyMeld/"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=9e7581cef5645475fcefebdc15ed7abf"
SRC_URI[md5sum] = "3ccc78cd79cffd63a751ad7684c02c91"
PYPI_PACKAGE = "meld3"

